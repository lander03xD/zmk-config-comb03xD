## boards/shields/comb03xD/Kconfig.shield
```kconfig
# No whitespace after the comma or in your keyboard name!
config COMB03XD
    def_bool $(shields_list_contains,comb03xD)
```
